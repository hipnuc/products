#include <stdio.h>
#include "oem_decode.h"

oem_raw_t oem_raw;

uint8_t data[] ={0xAA, 0x44, 0x12, 0x1C, 0x2A, 0x00, 0x02, 0x20, 0x48, 0x00, 0x00, 0x00,
0x90, 0xB4, 0x93, 0x05, 0xB0, 0xAB, 0xB9, 0x12, 0x00, 0x00, 0x00, 0x00,
0x45, 0x61, 0xBC, 0x0A, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
0x1B, 0x04, 0x50, 0xB3, 0xF2, 0x8E, 0x49, 0x40, 0x16, 0xFA, 0x6B, 0xBE,
0x7C, 0x82, 0x5C, 0xC0, 0x00, 0x60, 0x76, 0x9F, 0x44, 0x9F, 0x90, 0x40,
0xA6, 0x2A, 0x82, 0xC1, 0x3D, 0x00, 0x00, 0x00, 0x12, 0x5A, 0xCB, 0x3F,
0xCD, 0x9E, 0x98, 0x3F, 0xDB, 0x66, 0x40, 0x40, 0x00, 0x30, 0x30, 0x30,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0B, 0x0B, 0x00, 0x00,
0x00, 0x06, 0x00, 0x03, 0x42, 0xdc, 0x4c,0x48};

int main(int argc, char *argv[]) {
    printf("Hello World\n");
    int oemStatus; 

    /* decode oem */
    for(int i=0; i< sizeof(data); i++){
        oemStatus =input_oem(&oem_raw, data[i]);
        if(oemStatus ==1){
            switch (oem_raw.type){
                case OEM_ID_AGRIC:    printf("AGRIC"); break;
                case OEM_ID_BESTXYZ:  printf("BESTXYZ"); break;
                case OEM_ID_BESTPOS:  printf("BESTPOS"); break;
                case OEM_ID_HEADING:  printf("HEADING"); break;
                case OEM_ID_ANTENNA:  printf("ANTENNA"); break;
                case OEM_ID_INSPVAX:  printf("INSPVAX"); break;
                case OEM_ID_RAWIMUX:  printf("RAWIMUX"); break;
                case OEM_ID_GNSSRCV:  printf("GNSSRCV"); break;
                default:    break;
            }
        }
    }
    return 0;
}
