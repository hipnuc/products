#include <stdio.h>
#include "nmea_decode.h"

nmea_raw_t nmea_raw;

uint8_t data[] ={
0x24, 0x47, 0x50, 0x47, 0x47, 0x41, 0x2c, 0x30, 0x32, 0x35, 0x33, 0x34, 0x30, 0x2e, 0x36, 0x30,
0x2c, 0x34, 0x30, 0x31, 0x32, 0x2e, 0x32, 0x38, 0x34, 0x30, 0x32, 0x36, 0x34, 0x2c, 0x4e, 0x2c,
0x31, 0x31, 0x36, 0x31, 0x33, 0x2e, 0x35, 0x38, 0x33, 0x33, 0x39, 0x35, 0x36, 0x2c, 0x45, 0x2c,
0x31, 0x2c, 0x31, 0x32, 0x2c, 0x30, 0x2e, 0x30, 0x2c, 0x37, 0x31, 0x2e, 0x33, 0x30, 0x34, 0x2c,
0x4d, 0x2c, 0x2d, 0x38, 0x2e, 0x34, 0x32, 0x34, 0x2c, 0x4d, 0x2c, 0x30, 0x2e, 0x30, 0x2c, 0x30,
0x30, 0x30, 0x30, 0x2a, 0x36, 0x42, 0x0a, 0x24, 0x47, 0x50, 0x52, 0x4d, 0x43, 0x2c, 0x30, 0x32
};

int main(int argc, char *argv[]) {
    printf("Hello World\n");
    int nmeaStatus; 

    /* decode oem */
    for(int i=0; i< sizeof(data); i++){
        nmeaStatus =input_nmea(&nmea_raw, data[i]);
        if(nmeaStatus ==1){
            if (!strncmp(nmea_raw.type, "GGA", 3))
            {
                printf("GGA");
            }
            else if (!strncmp(nmea_raw.type, "RMC", 3))
            {
                printf("RMC");
            }
            else if (!strncmp(nmea_raw.type, "GSV", 3))
            {
                printf("GSV");
            }
            else if (!strncmp(nmea_raw.type, "GSA", 3))
            {
                printf("GSA");
            }
            else if (!strncmp(nmea_raw.type, "SXT", 3))
            {
                printf("SXT");
            }
        }
    }
    return 0;
}
